# Keil uVision project master.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: master
  c flags: Optimize=8 SizeSpeed=1
  c include: .;..;..\..;C:\Silabs\MCU\INC;..\..\RFM69-master
  group Source Group 1
    ./: STARTUP.A51
    ../: main.c
    ../Configurator_Project/: config.c
    ../../: retarget.c
    ../../RFM69-master/: RFM69.c
