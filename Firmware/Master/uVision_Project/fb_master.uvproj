# Keil uVision project fb_master.uvproj, settings and files
target Master (MCS-51)
  device: C8051F920 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: master
  c flags: Optimize=8 SizeSpeed=1
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
  group Common
    ../../: fb_c8051f920_startup.a51 fb_common.c fb_messages.c fb_retarget.c
    ../../RFM69/: RFM69.c
  group Master
    ../: fb_master_main.c
    ../Configurator_Project/: fb_master_config.c
