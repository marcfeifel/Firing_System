# Keil uVision project fb_remote.uvproj, settings and files
target Remote_0 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE0
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
  group Common
    ../../: fb_c8051f920_startup.a51 fb_common.c fb_messages.c fb_flash.c
    ../../RFM69/: RFM69.c
  group Remote
    ../Configurator_Project/: fb_remote_config.c
    ../: fb_remote_main.c fb_remote_cue_control.c fb_remote_program_run.c fb_messages_remote.c fb_remote_program_store.c
target Remote_1 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE1
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
target Remote_2 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE2
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
target Remote_3 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE3
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
target Remote_4 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE4
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
target Remote_5 (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c define: NODEID_LOCAL=NODEID_REMOTE5
  c include: .;..;..\..;..\..\Silabs\;..\..\RFM69
