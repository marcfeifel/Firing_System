# Keil uVision project slave.uvproj, settings and files
target Slave (MCS-51)
  device: C8051F920 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: slave
  c flags: Optimize=8 SizeSpeed=1
  c include: .;..;..\..;C:\Silabs\MCU\INC;..\..\RFM69-master
  group Common
    ../../: mf_common.c retarget.c
    ../../RFM69-master/: RFM69.c
    ./: STARTUP.A51
  group Slave
    ../Configurator_Project/: config.c
    ../: main.c
